# Keil uVision project c-copter.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F303CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: c-copter +hex
  BeforeMake: python ..\tools\gen_param.py ../
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: F3_EVO,STM32F303xC,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT=1,__USE_C99_MATH
  c include: ..\src\bsp;..\src\bsp\CMSIS\CM4\CoreSupport;..\src\bsp\CMSIS\CM4\DeviceSupport\ST\STM32F30x;..\src\bsp\STM32F30x_StdPeriph_Driver\inc;..\src\driver;..\src\link\mavlink;..\src\link\mavlink\common;..\src\link;..\src;..\src\mathlib;..\src\utils;..\src\utils\geo;..\src\utils\geo_lookup;..\src\config;..\src\modules;..\src\pilot;..\src\param;..\src\link\wwlink;..\src\pilot\estimator;..\src\pilot\navigator
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group cmsis
    ../src/bsp/: system_stm32f30x.c
    ../src/bsp/CMSIS/CM4/DeviceSupport/ST/STM32F30x/startup/arm/: startup_stm32f303xc.s
  group STM32F30x_StdPeriph_Driver
    ../src/bsp/STM32F30x_StdPeriph_Driver/src/: stm32f30x_dma.c stm32f30x_exti.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_spi.c
  group config
    ../src/config/: board.h chip.h version.c ff.param
  group driver
    ../src/driver/: hmc5883.c i2c.c mpu6050.c ms5611.c serial.c spi.c spi_flash.c timer.c
  group mavlink
    ../src/link/mavlink/: checksum.h mavlink_conversions.h mavlink_helpers.h mavlink_types.h protocol.h
    ../src/link/mavlink/common/: common.h mavlink.h mavlink_msg_actuator_control_target.h mavlink_msg_adsb_vehicle.h mavlink_msg_altitude.h mavlink_msg_att_pos_mocap.h mavlink_msg_attitude.h mavlink_msg_attitude_quaternion.h mavlink_msg_attitude_quaternion_cov.h mavlink_msg_attitude_target.h mavlink_msg_auth_key.h mavlink_msg_autopilot_version.h mavlink_msg_battery_status.h mavlink_msg_camera_trigger.h mavlink_msg_change_operator_control.h mavlink_msg_change_operator_control_ack.h mavlink_msg_collision.h mavlink_msg_command_ack.h mavlink_msg_command_int.h mavlink_msg_command_long.h mavlink_msg_control_system_state.h mavlink_msg_data_stream.h mavlink_msg_data_transmission_handshake.h mavlink_msg_debug.h mavlink_msg_debug_vect.h mavlink_msg_distance_sensor.h mavlink_msg_encapsulated_data.h mavlink_msg_estimator_status.h mavlink_msg_extended_sys_state.h mavlink_msg_file_transfer_protocol.h mavlink_msg_follow_target.h mavlink_msg_global_position_int.h mavlink_msg_global_position_int_cov.h mavlink_msg_global_vision_position_estimate.h mavlink_msg_gps_global_origin.h mavlink_msg_gps_inject_data.h mavlink_msg_gps_input.h mavlink_msg_gps_raw_int.h mavlink_msg_gps_rtcm_data.h mavlink_msg_gps_rtk.h mavlink_msg_gps_status.h mavlink_msg_gps2_raw.h mavlink_msg_gps2_rtk.h mavlink_msg_heartbeat.h mavlink_msg_high_latency.h mavlink_msg_highres_imu.h mavlink_msg_hil_actuator_controls.h mavlink_msg_hil_controls.h mavlink_msg_hil_gps.h mavlink_msg_hil_optical_flow.h mavlink_msg_hil_rc_inputs_raw.h mavlink_msg_hil_sensor.h mavlink_msg_hil_state.h mavlink_msg_hil_state_quaternion.h mavlink_msg_home_position.h mavlink_msg_landing_target.h mavlink_msg_local_position_ned.h mavlink_msg_local_position_ned_cov.h mavlink_msg_local_position_ned_system_global_offset.h mavlink_msg_log_data.h mavlink_msg_log_entry.h mavlink_msg_log_erase.h mavlink_msg_log_request_data.h mavlink_msg_log_request_end.h mavlink_msg_log_request_list.h mavlink_msg_manual_control.h mavlink_msg_manual_setpoint.h mavlink_msg_memory_vect.h mavlink_msg_message_interval.h mavlink_msg_mission_ack.h mavlink_msg_mission_clear_all.h mavlink_msg_mission_count.h mavlink_msg_mission_current.h mavlink_msg_mission_item.h mavlink_msg_mission_item_int.h mavlink_msg_mission_item_reached.h mavlink_msg_mission_request.h mavlink_msg_mission_request_int.h mavlink_msg_mission_request_list.h mavlink_msg_mission_request_partial_list.h mavlink_msg_mission_set_current.h mavlink_msg_mission_write_partial_list.h mavlink_msg_named_value_float.h mavlink_msg_named_value_int.h mavlink_msg_nav_controller_output.h mavlink_msg_optical_flow.h mavlink_msg_optical_flow_rad.h mavlink_msg_param_map_rc.h mavlink_msg_param_request_list.h mavlink_msg_param_request_read.h mavlink_msg_param_set.h mavlink_msg_param_value.h mavlink_msg_ping.h mavlink_msg_position_target_global_int.h mavlink_msg_position_target_local_ned.h mavlink_msg_power_status.h mavlink_msg_radio_status.h mavlink_msg_raw_imu.h mavlink_msg_raw_pressure.h mavlink_msg_rc_channels.h mavlink_msg_rc_channels_override.h mavlink_msg_rc_channels_raw.h mavlink_msg_rc_channels_scaled.h mavlink_msg_request_data_stream.h mavlink_msg_resource_request.h mavlink_msg_safety_allowed_area.h mavlink_msg_safety_set_allowed_area.h mavlink_msg_scaled_imu.h mavlink_msg_scaled_imu2.h mavlink_msg_scaled_imu3.h mavlink_msg_scaled_pressure.h mavlink_msg_scaled_pressure2.h mavlink_msg_scaled_pressure3.h mavlink_msg_serial_control.h mavlink_msg_servo_output_raw.h mavlink_msg_set_actuator_control_target.h mavlink_msg_set_attitude_target.h mavlink_msg_set_gps_global_origin.h mavlink_msg_set_home_position.h mavlink_msg_set_mode.h mavlink_msg_set_position_target_global_int.h mavlink_msg_set_position_target_local_ned.h mavlink_msg_sim_state.h mavlink_msg_statustext.h mavlink_msg_sys_status.h mavlink_msg_system_time.h mavlink_msg_terrain_check.h mavlink_msg_terrain_data.h mavlink_msg_terrain_report.h mavlink_msg_terrain_request.h mavlink_msg_timesync.h mavlink_msg_v2_extension.h mavlink_msg_vfr_hud.h mavlink_msg_vibration.h mavlink_msg_vicon_position_estimate.h mavlink_msg_vision_position_estimate.h mavlink_msg_vision_speed_estimate.h mavlink_msg_wind_cov.h testsuite.h version.h
  group link
    ../src/link/: link_mavlink.c mavlink_log.c link_wwlink.c
  group pilot
    ../src/pilot/: est.c mixer.c commander.c att_control.c navigator.c sensor.c alt_control.c
  group modules
    ../src/modules/: log.c mtd.c log_messages.h param.c cli.c scheduler.c
  group utils
    ../src/utils/: fifo.c rotation.c perf.c lpf.c pid.c mm.c trigger.c
  group mathlib
    ../src/mathlib/: mathlib.c matrix.c quaternion.c vector.c srcdkf.c dcm.c
  group launch
    ../src/: main.c
  group param
    ../src/param/: param_api.c
  group wwlink
    ../src/link/wwlink/: wwlink.h wwlink_control.h wwlink_crc.h wwlink_helpers.h wwlink_status.h wwlink_system.h
  group estimator
    ../src/pilot/estimator/: att_est_cf.c att_est_q.c
  group navigator
    ../src/pilot/navigator/: stabilize.c althold.c land.c
software components: CMSIS:CORE 5.1.1
